# Keil uVision project Project.uvprojx, settings and files
target STM32H7B3I_DISCO_2_Images_UserApp (6140000::V6.14::ARMCLANG)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: UserApp
  AfterMake: fromelf #L --bincombined --output=$..\..\@L.bin
  AfterMake: .\..\..\2_Images_SECoreBin\MDK-ARM\postbuild.bat . #L @L.bin 1 1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7B3xxQ,USE_STM32H7B3I_DISCOVERY
  c include: ../Inc;../../../../../../Drivers/BSP/STM32H7B3I-DK;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/BASIC_GUI;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../2_Images_SECoreBin/Inc;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: UserApp.sct
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c com.c common.c fw_update_app.c se_user_code.c test_protections.c ymodem.c flash_if.c stm32h7xx_it.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Drivers/BSP/STM32H7B3I-DK
    ../../../../../../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_exti.c stm32h7xx_hal_mdma.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/MDK-ARM/STM32H7B3I_DISCO/Exe/: se_interface_appli.txt
software components: CMSIS:CORE 5.4.0
