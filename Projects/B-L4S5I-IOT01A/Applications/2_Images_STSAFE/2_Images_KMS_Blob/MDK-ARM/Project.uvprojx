# Keil uVision project Project.uvprojx, settings and files
target B-L4S5I-IOT01_2_Images_KMS_Blob (6120000::V6.12::.\ARMCLANG)
  device: STM32L4S5VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.1
  cpu: CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: KMS_Blob
  AfterMake: fromelf #L --bin --output=$L..\..\@L.bin
  AfterMake: postbuild.bat .  $L..\..\@L 1
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L4S5xx,USE_HAL_DRIVER,USE_STM32L4S5I_IOT01
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L4S5I-IOT01A;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Key_Management_Services/Core;..\..\2_Images_SECoreBin\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\KMS_Blob.sct
  link misc: --diag_suppress L6305W
  group Application/User
    ../Src/: kms_blob_example_keys.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
