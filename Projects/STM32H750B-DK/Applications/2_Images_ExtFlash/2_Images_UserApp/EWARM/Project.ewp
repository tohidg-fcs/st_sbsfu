# IAR project Project.ewp, settings and files
configuration STM32H750B_DISCO_2_Images_UserApp (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750XB ST STM32H750XB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H750xx; USE_STM32H750B_DISCOVERY
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H750B-DK; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\2_Images_SECoreBin\Inc; ..\..\2_Images_SBSFU\SBSFU\App; ..\..\Linker_Common\EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\UserApp.bin
  postbuild: cmd /C "cmd /C ..\..\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "UserApp.bin" 1 1"
  ILINK.IlinkOutputFile: STM32H750B_DISCO.out
  ILINK.IlinkKeepSymbols: APP_LOADER_BIN
  ILINK.IlinkIcfFile: stm32h750xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c com.c common.c fw_update_app.c se_user_code.c test_protections.c ymodem.c flash_if.c stm32h7xx_it.c
  group Application/SFU_Services
    ../Src/: sfu_app_new_image.c
  group Application/EWARM
    ./: startup_stm32h750xx.s
  group Drivers/BSP/STM32H750B-DK
    ../../../../../../Drivers/BSP/STM32H750B-DK/: stm32h750b_discovery.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/STM32_Secure_Engine
    ../../2_Images_SBSFU/EWARM/: se_interface_appli.o
