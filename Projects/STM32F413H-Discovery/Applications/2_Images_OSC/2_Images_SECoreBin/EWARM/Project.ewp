# IAR project Project.ewp, settings and files
configuration STM32F413H_DISCOVERY_2_Images_SECoreBin (ARM, debug)
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F413xx; USE_HAL_DRIVER; USE_STM32F413H_DISCOVERY; MBEDTLS_CONFIG_FILE=<se_mbedtls_config.h>
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F413H-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Key; ..\..\2_Images_SBSFU\SBSFU\App; ..\..\2_Images_SBSFU\SBSFU\Target; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\SE_Core.bin
  prebuild: cmd /C "cmd /C prebuild.bat "$PROJ_DIR$" "
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f413xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: SE_CallGate
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: se_low_level.c se_crypto_bootloader.c
    ../Inc/: se_mbedtls_config.h
  group Application/EWARM
    ./: se_key.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c
  group Middlewares/Third_Party/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c bignum.c bignum_core.c camellia.c cipher.c cipher_wrap.c constant_time.c ecdsa.c ecp.c ecp_curves.c gcm.c md.c platform.c platform_util.c sha256.c
