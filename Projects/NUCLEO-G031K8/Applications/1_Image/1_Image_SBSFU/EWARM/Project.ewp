# IAR project Project.ewp, settings and files
configuration NUCLEO-G031K8_1_Image_SBSFU (ARM, debug)
  General.OGChipSelectEditMenu: STM32G031K8 ST STM32G031K8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G031xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\..\..\..\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32G0xx_Nucleo_32; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\Core\Inc; ..\SBSFU\App; ..\SBSFU\Target; ..\..\1_Image_SECoreBin\Inc; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Interface; ..\..\..\..\..\..\Drivers\BSP\STM32G0xx_Nucleo_32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  postbuild: "$TOOLKIT_DIR$\bin\isymexport.exe" --edit "steering_file.txt" "$TARGET_PATH$" "$PROJ_DIR$.\se_interface_appli.o"
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkKeepSymbols: SE_CORE_Bin
  ILINK.IlinkIcfFile: stm32g031xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_loader.c sfu_boot.c sfu_com_loader.c sfu_com_trace.c sfu_error.c sfu_test.c sfu_fwimg_common.c sfu_new_image.c sfu_mpu_isolation.c
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level.c sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level_security.c
  group Application/EWARM
    ./: sfu_se_mpu.s startup_stm32g031xx.s
  group Drivers/BSP/STM32G0xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32G0xx_Nucleo_32/: stm32g0xx_nucleo_32.c
  group Drivers/STM32G0xx_HAL_Driver
    ../../../../../../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_flash.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c
