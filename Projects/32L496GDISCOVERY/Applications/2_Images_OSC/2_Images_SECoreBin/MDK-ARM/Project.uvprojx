# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery_2_Images_SECoreBin (6140000::V6.14::ARMCLANG)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L496xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<se_mbedtls_config.h>,IT_MANAGEMENT
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/mbedtls/include;../../../../../../Middlewares/Third_Party/mbedtls/include/mbedtls;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../2_Images_SBSFU/SBSFU/App;../../2_Images_SBSFU/SBSFU/Target;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: SECoreBin.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Middlewares/Third_Party/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c asn1parse.c asn1write.c bignum.c bignum_core.c camellia.c cipher.c cipher_wrap.c constant_time.c ecdsa.c ecp.c ecp_curves.c gcm.c hmac_drbg.c md.c platform.c platform_util.c sha256.c
  group Application/User
    ../Src/: se_crypto_bootloader.c se_low_level.c
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s data_init.c se_key.s
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_firewall.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_crc.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_exception.c se_startup.c se_stack_smuggler_it_mngt_ARM.s se_fwimg.c se_user_application.c se_utils.c
software components: CMSIS:CORE 5.4.0
