# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-L152RE_2_Images_SECoreBin (6140000::V6.14::ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L152xE,USE_STM32L1XX_NUCLEO,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L1xx_Nucleo;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../2_Images_SBSFU/SBSFU/App;../../2_Images_SBSFU/SBSFU/Target;../../Linker_Common/MDK-ARM;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L1/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  scatter file: Project.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Application/MDK-ARM
    ./: data_init.c se_key.s
  group Application/User
    ../Src/: se_crypto_bootloader.c se_low_level.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_crc.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L1/Lib/: STM32CryptographicV3.0.0_CM3_KEIL_slsm1elfspf.lib
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_crypto_common.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c se_stack_smuggler_ARM.s
software components: CMSIS:CORE 5.4.0
