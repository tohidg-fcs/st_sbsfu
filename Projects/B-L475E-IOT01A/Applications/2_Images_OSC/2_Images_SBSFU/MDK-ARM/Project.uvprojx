# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_2_Images_SBSFU (6140000::V6.14::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.1
  cpu: IRAM1(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SBSFU
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01,IT_MANAGEMENT
  c misc: -Wno-format
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stmpe1600;../../../../../../Drivers/BSP/Components/stmpe811;../Core/Inc;../SBSFU/App;../SBSFU/Target;../../2_Images_SECoreBin/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Interface;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: SBSFU.sct
  link misc: --symdefs=se_interface.txt
--keep=SE_CoreBin.o(SE_CORE_Bin)
--keep=SE_UserHandlerWrapper
--diag_suppress L6312W
  group Application/Core
    ../Core/Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
    ./: SE_CoreBin.s
  group Application/SBSFU/App
    ../SBSFU/App/: sfu_test.c sfu_boot.c sfu_new_image.c sfu_com_loader.c sfu_com_trace.c sfu_loader.c sfu_error.c sfu_fwimg_common.c sfu_fwimg_swap.c sfu_fwimg_no_swap.c
  group Application/SBSFU/Target
    ../SBSFU/Target/: sfu_low_level_flash.c sfu_low_level_flash_int.c sfu_low_level_flash_ext.c sfu_low_level.c sfu_low_level_security.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_uart.c stm32l4xx_hal_crc.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_adc.c stm32l4xx_hal_spi.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_gpio.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_flash.c stm32l4xx_hal_rtc.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi_ex.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_interface_application.c se_interface_bootloader.c se_interface_common.c se_interface_exception_ARM.s
software components: CMSIS:CORE 5.4.0
