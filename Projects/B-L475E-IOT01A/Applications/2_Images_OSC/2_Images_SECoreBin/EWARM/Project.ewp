# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01_2_Images_SECoreBin (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_HAL_DRIVER; USE_STM32L475E_IOT01; MBEDTLS_CONFIG_FILE=<se_mbedtls_config.h>; IT_MANAGEMENT
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\B-L475E-IOT01; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Key; ..\..\2_Images_SBSFU\SBSFU\App; ..\..\2_Images_SBSFU\SBSFU\Target; ..\..\Linker_Common\EWARM; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\SE_Core.bin
  prebuild: cmd /C "cmd /C prebuild.bat "$PROJ_DIR$" "
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\Linker_Common\EWARM\
  ILINK.IlinkProgramEntryLabel: SE_CallGate
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: se_low_level.c se_crypto_bootloader.c
    ../Inc/: se_mbedtls_config.h
  group Application/EWARM
    ./: se_key.s startup_stm32l475xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_firewall.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_exception.c se_fwimg.c se_startup.c se_user_application.c se_utils.c se_stack_smuggler_it_mngt_IAR.s
  group Middlewares/Third_Party/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c bignum.c bignum_core.c camellia.c cipher.c cipher_wrap.c constant_time.c ecdsa.c ecp.c ecp_curves.c gcm.c md.c platform.c platform_util.c sha256.c
