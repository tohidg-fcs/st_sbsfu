# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_2_Images_SECoreBin (6140000::V6.14::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.1
  cpu: IRAM1(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/stmpe1600;../../../../../../Drivers/BSP/Components/stmpe811;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L4/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../2_Images_SBSFU/SBSFU/App;../../2_Images_SBSFU/SBSFU/Target;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: SECoreBin.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6314W
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: se_key.s startup_stm32l475xx.s data_init.c
  group Application/User
    ../Src/: se_crypto_bootloader.c se_low_level.c
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32L4/Lib/: STM32CryptographicV3.0.0_CM4_KEIL_slsm1elfspf.lib
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ex.c stm32l4xx_hal_firewall.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_crc.c
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_exception.c se_fwimg.c se_crypto_common.c se_user_application.c se_stack_smuggler_ARM.s se_startup.c se_utils.c
software components: CMSIS:CORE 5.4.0
