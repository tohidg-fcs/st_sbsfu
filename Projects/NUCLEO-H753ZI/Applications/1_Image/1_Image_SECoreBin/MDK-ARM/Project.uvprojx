# Keil uVision project Project.uvprojx, settings and files
target STM32H753ZI-Nucleo_1_Image_SECoreBin (6140000::V6.14::ARMCLANG)
  device: STM32H753ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32H753xx, USE_STM32H7XX_NUCLEO_144
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32H7/Inc;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../1_Image_SBSFU/SBSFU/App;../../1_Image_SBSFU/SBSFU/Target;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: SECoreBin.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Application/MDK-ARM
    ./: data_init.c se_key.s
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_crypto_common.c se_callgate.c se_startup.c se_utils.c se_fwimg.c se_stack_smuggler_ARM.s se_user_application.c se_exception.c
  group Application/User
    ../Src/: se_crypto_bootloader.c se_low_level.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_flash.c
  group Doc
    ../: readme.txt
  group Middlewares/STM32_Cryptographic
    ../../../../../../Middlewares/ST/STM32_Cryptographic/Fw_Crypto/STM32H7/Lib/: STM32CryptographicV3.1.1_STM32H7_KEIL_slsm1elfspf_ARMCCv5.lib
software components: CMSIS:CORE 5.4.0
